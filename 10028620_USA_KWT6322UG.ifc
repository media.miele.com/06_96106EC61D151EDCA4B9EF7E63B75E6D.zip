Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-02-15T14:01:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 15 14:01:39 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\2da82831-cd1e-43b8-a147-8c72bca6a6df\34cdc5fa-85b7-4e64-a365-34591595be2b\ifc * Database version: 5507 * Database creation date: Tue Feb 15 14:01:38 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 15 14:01:38 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 15 14:01:38 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10028620_USA_KWT6322UG:36632200_USA_10028620_KWT6322UG, (2)
In: Default
Type - Material: Spruce
Type - Pset_BuildingElementProxyCommon - Reference: 36632200_USA_10028620_KWT6322UG
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: wine cabinet
Type - Pset_QuantityTakeOff - Reference: 36632200_USA_10028620_KWT6322UG
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 820 mm; Depth: 577 mm
Material: Spruce, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel_Black, z_Miele_Design_Glass, z_Miele_Connection_Electric, Polypropylene, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
